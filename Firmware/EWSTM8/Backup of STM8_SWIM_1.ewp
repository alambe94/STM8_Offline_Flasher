# IAR project Backup of STM8_SWIM_1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x00
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\inc; ..\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: MicroScope.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group inc
    ../inc/: at24cxx.h i2c.h millis.h stm8s_conf.h stm8s_it.h
  group src
    ../src/: at24cxx.c i2c.c main.c millis.c stm8_swim.c stm8s_it.c
  group STM8S_StdPeriph_Driver
    ../STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c stm8s_tim2.c stm8s_tim4.c
